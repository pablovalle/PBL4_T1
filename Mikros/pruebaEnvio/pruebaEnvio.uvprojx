# Keil uVision project pruebaEnvio.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: pruebaEnvio
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group src
    ./: pruebaEnvioMain.c ourCom.c ourExti.c ourRccGpio.c sysClockAndTick.c ourUsart.c ourBuffer.c
  group include
    ./: ourCom.h ourExti.h ourRccGpio.h sysClockAndTick.h ourUsart.h ourBuffer.h
software components: CMSIS:CORE 5.3.0, Device:Startup 2.6.3
